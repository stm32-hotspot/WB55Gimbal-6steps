<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\WB55Gimbal-6steps.ewp</path>
  </project>
  <batchBuild />
</workspace>
