# IAR project WB55Gimbal-6steps.ewp, settings and files
configuration WB55Gimbal-6steps (ARM, debug)
  General.OGChipSelectEditMenu: STM32WB55RG ST STM32WB55RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32WB55xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/Any/Inc; ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/G4xx/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc; ../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32WBxx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: WB55Gimbal-6steps.hex
  ILINK.IlinkOutputFile: WB55Gimbal-6steps.out
  ILINK.IlinkIcfFile: stm32wb55xx_flash_cm4.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/MCSDKv6/Any
    ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c mcpa.c ntc_temperature_sensor.c pid_regulator.c pwm_common_sixstep.c pwmc_3pwm.c r_divider_bus_voltage_sensor.c revup_ctrl_sixstep.c speed_ctrl.c speed_pos_fdbk.c virtual_speed_sensor.c
  group Application/MCSDKv6/G4xx
    ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/G4xx/Src/: g4xx_bemf_ADC_fdbk.c
  group Application/User/Core
    ../Core/Src/: aspep.c main.c mc_api.c mc_app_hooks.c mc_config.c mc_configuration_registers.c mc_interface.c mc_math.c mc_parameters.c mc_tasks.c mcp.c mcp_config.c motorcontrol.c register_interface.c regular_conversion_manager.c stm32g4xx_mc_it.c stm32wbxx_hal_msp.c stm32wbxx_it.c usart_aspep_driver.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal.c stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_exti.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c stm32wbxx_ll_adc.c stm32wbxx_ll_rcc.c
