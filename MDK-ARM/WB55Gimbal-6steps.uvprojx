# Keil uVision project WB55Gimbal-6steps.uvprojx, settings and files
target WB55Gimbal-6steps (6210000::V6.21::ARMCLANG)
  device: STM32WB55RGVx STMicroelectronics
  pack: Keil.STM32WBxx_DFP.1.3.0
  cpu: IRAM(0x20000008-0x2002FC07) IROM(0x08000000-0x807FFFF) IRAM2(0x20030000-0x200323FF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: WB55Gimbal-6steps +hex
  c flags: Optim=5 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32WB55xx
  c include: ../Core/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc;../Drivers/STM32WBxx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32WBxx/Include;../Drivers/CMSIS/Include;..\MCSDK_v6.2.1-Full\MotorControl\MCSDK\MCLib\Any\Inc;..\MCSDK_v6.2.1-Full\MotorControl\MCSDK\MCLib\G4xx\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000008 size 0x2fc00
  memory RVCT10: RAM 0x20030000 size 0x2400
  scatter file: stm32wb55xx_flash_cm4.sct
  link misc: --diag_suppress L6314W
--diag_suppress 1296
  group Application/MDK-ARM
    ./: startup_stm32wb55xx_cm4.s
  group Application/User/Core
    ../Core/Src/: main.c stm32wbxx_it.c stm32wbxx_hal_msp.c aspep.c mc_api.c mc_app_hooks.c mc_config.c mc_configuration_registers.c mc_interface.c mc_math.c mc_parameters.c mc_tasks.c mcp.c mcp_config.c motorcontrol.c register_interface.c regular_conversion_manager.c stm32g4xx_mc_it.c usart_aspep_driver.c
  group MCSDKv6/Any
    ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/Any/Src/: bus_voltage_sensor.c mcpa.c ntc_temperature_sensor.c pid_regulator.c pwm_common_sixstep.c pwmc_3pwm.c r_divider_bus_voltage_sensor.c revup_ctrl_sixstep.c speed_ctrl.c speed_pos_fdbk.c virtual_speed_sensor.c
  group MCSDKv6/G4xx
    ../MCSDK_v6.2.1-Full/MotorControl/MCSDK/MCLib/G4xx/Src/: g4xx_bemf_ADC_fdbk.c
  group Drivers/STM32WBxx_HAL_Driver
    ../Drivers/STM32WBxx_HAL_Driver/Src/: stm32wbxx_hal_adc.c stm32wbxx_hal_adc_ex.c stm32wbxx_ll_adc.c stm32wbxx_hal_rcc.c stm32wbxx_ll_rcc.c stm32wbxx_hal_rcc_ex.c stm32wbxx_hal_flash.c stm32wbxx_hal_flash_ex.c stm32wbxx_hal_gpio.c stm32wbxx_hal_hsem.c stm32wbxx_hal_dma.c stm32wbxx_hal_dma_ex.c stm32wbxx_hal_pwr.c stm32wbxx_hal_pwr_ex.c stm32wbxx_hal_cortex.c stm32wbxx_hal.c stm32wbxx_hal_exti.c stm32wbxx_hal_tim.c stm32wbxx_hal_tim_ex.c stm32wbxx_hal_uart.c stm32wbxx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32wbxx.c
software components: CMSIS:CORE 5.6.0
